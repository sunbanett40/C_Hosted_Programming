V1 1 0 5.0
R1 1 2 1000.0
R2 2 3 2000.0
R3 2 3 2000.0
R4 3 4 1000.0
R5 4 5 500.0
