V1 1 0 6.0
V2 4 0 6.0
R1 1 2 1000.0
R2 1 3 1000.0
R3 1 4 1000.0
R4 3 2 1000.0
R5 4 2 1000.0
